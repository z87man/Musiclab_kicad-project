# Repository z87man/Musiclab_kicad-project

## KiCad design SP2T_PE42420_0mm254kappa_vertical_3x2/SP2T_PE42420_0mm254kappa_vertical_3x2.kicad_pcb

Parts:
C1: 10 uF; C_0402_1005Metric
C2: 1uF; C_0402_1005Metric
C3: 0.1 uF; C_0402_1005Metric
C4: 0.1nF; C_0402_1005Metric
C5, C6, C7: 100 pF; C_0402_1005Metric
D1: D_Schottky; D_SOD-323
D2: TVS SMAJ3.3A-TP; TVS DIOM5226X230N; Mouser Part Number 833-SMAJ6.0A-TP
D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: Bead MG1608-152Y; Bead0603 BEADC1608X100N; Mouser Part Number 652-MG1608-152Y
IC1: Switch_PE42420F-Z; Switch_PE42420FZ; Manufacturer_Part_Number PE42420F-Z
J1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4: Conn_02x02_Odd_Even; PinSocket_2x02_P2.54mm_Vertical
Q1: Q_PMOS_GSD; SOT-23
R1, R2: 10 kohm; R_0402_1005Metric
R4, R5: 4.7K; R_0402_1005Metric
SMA1, SMA3, SMA4: SMA_KHD_Back
U4: Outline_3x2_cavity_1.5mm

Connections:
/VCC: C3.2, C4.2, FB1.2, IC1.20 (VDD), J4.2, J4.4
GND: C1.1, C2.1, C3.1, C4.1, D2.2 (A), IC1.1 (GND_1), IC1.2 (GND_2), IC1.4 (GND_3), IC1.5 (GND_4), IC1.6 (GND_5), IC1.7 (GND_6), IC1.9 (GND_7), IC1.10 (GND_8), IC1.11 (GND_9), IC1.12 (GND_10), IC1.14 (GND_11), IC1.15 (GND_12), IC1.18 (GND_13), IC1.19 (GND_14), IC1.21 (EP), J1.1, R1.1, R2.1, R4.1, R5.1, SMA1.2, SMA3.2, SMA4.2, U4.1
unnamed: C5.1, SMA3.1
unnamed: C6.1, SMA1.1
unnamed: C7.1, SMA4.1
unnamed: D1.2 (A), Q1.1 (G), R1.2
unnamed: C1.2, C2.2, D1.1 (K), D2.1 (K), D3.1 (K), FB1.1, Q1.2 (S)
unnamed: D3.2 (A), R2.2
unnamed: IC1.17 (CTRL1), J4.1, R5.2
unnamed: IC1.16 (CTRL2), J4.3, R4.2
unnamed: C5.2, IC1.3 (RF1)
unnamed: C7.2, IC1.13 (RF2)
unnamed: C6.2, IC1.8 (RFC)
unnamed: J1.2, Q1.3 (D)

Notes on the sheet:
1.防反接
PMOS： Package_TO_SOT_SMD:SOT-23
footprint：查询SMAJ3.3A DIOM5226X230N
4. 电源滤波
D3：Diode_SMD:D_SOD-323
3. 电源指示灯
滤特定高频频率噪声 看需求放置
5.磁珠0603
6.电源滤波
2.ESD及浪涌防护

Board: 4 copper layers, 46.4 x 33.7 mm, 23 parts (6 on the bottom side), 14 nets.

## KiCad design SP8T_PE426482_0508mmKAPPA/SP8T_PE426482_0508mmKAPPA.kicad_pcb

Parts:
C1, C13: 1uF; C_0402_1005Metric
C2: 0.1uF; C_0402_1005Metric
C3: 100 pF; C_0402_1005Metric
C4, C5, C6, C7, C8, C9, C10, C11, C12: 4700 pF; C_0402_1005Metric
IC1: Switch_PE426482A-X; QFN50P400X400X90-25N; Mouser Part Number 81-PE426482A-X
J2: Conn_02x04_Odd_Even; PinSocket_2x04_P2.54mm_Vertical_SMD
R1, R2, R3, R4: 4.7K; R_0402_1005Metric
SMA1, SMA3, SMA4, SMA5, SMA6, SMA7, SMA8, SMA9, SMA10: SMA_Edge_step_1
SMA2: JST_EH_S2B-EH_1x02_P2.50mm_Horizontal
U1, U2, U3, U4: via_GND

Connections:
/Vdd: C1.1, C2.1, C3.1, C13.1, IC1.8 (VDD), J2.4, J2.6, J2.8, R4.1, SMA2.2
GND: C1.2, C2.2, C3.2, C13.2, IC1.1 (LS), IC1.3 (GND_1), IC1.5 (GND_2), IC1.7 (GND_3), IC1.14 (GND_4), IC1.16 (GND_5), IC1.18 (GND_6), IC1.20 (GND), IC1.21 (GND_7), IC1.23 (GND_8), IC1.25 (EP), J2.2, R1.1, R2.1, R3.1, SMA1.2, SMA2.1, SMA3.2, SMA4.2, SMA5.2, SMA6.2, SMA7.2, SMA8.2, SMA9.2, SMA10.2, U1.1, U2.1, U3.1, U4.1
unnamed: C4.1, SMA1.1
unnamed: C5.1, SMA3.1
unnamed: C6.1, SMA4.1
unnamed: C7.2, SMA10.1
unnamed: C8.2, SMA9.1
unnamed: C9.2, SMA8.1
unnamed: C10.2, SMA5.1
unnamed: C11.2, SMA6.1
unnamed: C12.2, SMA7.1
unnamed: C10.1, IC1.24 (RF1)
unnamed: C6.2, IC1.2 (RF2)
unnamed: C5.2, IC1.4 (RF3)
unnamed: C4.2, IC1.6 (RF4)
unnamed: C7.1, IC1.13 (RF5)
unnamed: C8.1, IC1.15 (RF6)
unnamed: C9.1, IC1.17 (RF7)
unnamed: C12.1, IC1.19 (RF8)
unnamed: C11.1, IC1.22 (RFC)
unnamed: IC1.9 (V1), J2.7, R1.2
unnamed: IC1.10 (V2), J2.5, R2.2
unnamed: IC1.11 (V3), J2.3, R3.2
unnamed: IC1.12 (V4), J2.1, R4.2

Board: 2 copper layers, 64.0 x 55.0 mm, 33 parts (0 on the bottom side), 24 nets.

## KiCad design LNA_PM3_63GLN+_cavity_20231130/LNA_PM3_63GLN+_cavity_20231130.kicad_pcb

Parts:
C1, C2: 22 uF; C_0603_1608Metric_revised
C3: 1 nF; C_0603_1608Metric_revised
C4: 100 pF; C_0603_1608Metric_revised
C5: 4.7 uF; C_0603_1608Metric_revised
J1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
L1: 15 nH; L_0603_1608Metric_revised
SMA1, SMA2: SMA_KHD_Back
U1: PMA3-63GLN+
outline1: Outline_3x2_cavity_1.5mm

Connections:
/VDD: C3.1, C4.1, C5.1, J1.2, L1.1
GND: C3.2, C4.2, C5.2, J1.1, SMA1.2, SMA2.2, U1.1 (NC), U1.3 (NC), U1.4 (NC), U1.5 (NC), U1.6 (NC), U1.7 (NC), U1.9 (NC), U1.10 (NC), U1.11 (NC), U1.12 (NC), U1.13 (EP), outline1.1 (GND)
unnamed: C1.1, SMA1.1
unnamed: C2.2, SMA2.1
unnamed: C1.2, U1.2 (RFin)
unnamed: C2.1, L1.2, U1.8 (RFout&DCin)

Board: 2 copper layers, 46.4 x 33.7 mm, 11 parts (3 on the bottom side), 6 nets.

## KiCad design IF_Combiner/IF_combine_Noninverting/IF_combine_Noninverting.kicad_pcb

Parts:
C1, C2, C3, C7, C11: 4.7uf; C_0603_1608Metric
C5, C12: 1uf; C_0603_1608Metric
C8, C9, C10: 0.1uf; C_0402_1005Metric
IC1: MIC7300; SOT-23-5; Mouser Part Number 595-LMV321IDBVR
J1, J2, J4: Conn_01x02_Pin; SMA_KHD_Back
J3: Conn_01x02_Pin; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
R1, R2, R3, R4, R7, R8: 1k; C_0402_1005Metric
R5, R6: 33k; C_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Plated_Hole_D0.6mm
U1, U2, U3: SOIC-8_3.9x4.9mm_P1.27mm
outline2: Outline_4x2_cavity_20231207

Connections:
/Vcm_IF: C8.1, C9.1, C10.1, C12.1, IC1.1 (OUT), IC1.4 (1IN-), R1.1, R2.1
/Vdd: C2.1, IC1.5 (V+), J3.2, R5.2, U1.7 (V+), U2.7 (V+), U3.7 (V+)
GND: C2.2, C5.2, C8.2, C9.2, C10.2, C11.1, C12.2, IC1.2 (V-), J1.2, J2.2, J3.1, J4.2, R6.1, TP4.1, TP5.1, TP6.1, TP7.1, U1.4 (V-), U2.4 (V-), U3.4 (V-), outline2.1 (GND)
unnamed: C11.2, R8.2
unnamed: C5.1, IC1.3 (1IN+), R5.1, R6.2
unnamed: C1.1, J1.1, TP1.1
unnamed: C3.1, J2.1, TP2.1
unnamed: C7.2, J4.1, TP3.1
unnamed: R3.2, U1.2 (in-), U1.6 (Out)
unnamed: C1.2, R1.2, U1.3 (in+)
unnamed: R4.2, U2.2 (in-), U2.6 (Out)
unnamed: C3.2, R2.2, U2.3 (in+)
unnamed: C7.1, R7.1, U3.6 (Out)
unnamed: R3.1, R4.1, U3.3 (in+)
unnamed: R7.2, R8.1, U3.2 (in-)

Notes on the sheet:
+5V/+10V

Board: 4 copper layers, 59.0 x 33.6 mm, 34 parts (9 on the bottom side), 15 nets.

File IF_Combiner/IF_combine_Noninverting/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C2, C3, C7",0603,5,4.7uf,
"C10, C8, C9",0402,3,0.1uf,
"C12, C5",0603,2,1uf,
IC1,SOT-23-5,1,MIC7300,
"J1, J2, J4",SMA_KHD_Back,3,Conn_01x02_Pin,
J3,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
"R1, R2, R3, R4, R7, R8",0402,6,1k,
"R5, R6",0402,2,33k,
"TP1, TP2, TP3, TP4, TP5, TP6, TP7",TestPoint_Plated_Hole_D0.6mm,7,TestPoint,
"U1, U2, U3",SOIC-8_3.9x4.9mm_P1.27mm,3,~,
outline2,Outline_4x2_cavity_20231207,1,~,

## KiCad design TransmissionLine20250307_2Layer_FR4_1mm6/TransmissionLine20250307_2Layer_FR4_1mm6.kicad_pcb

Board: 2 copper layers, 65.7 x 82.9 mm, 22 parts (12 on the bottom side), 12 nets.

Parts:
SMA1, SMA2, SMA3, SMA4, SMA5, SMA6, SMA7, SMA8, SMA9, SMA10: SMA_Edge
SMA11, SMA12, SMA13, SMA14, SMA15, SMA16, SMA18, SMA20, SMA23, SMA24, SMA28, SMA30: SMA_KHD

Connections:
GND: SMA1.2, SMA2.2, SMA3.2, SMA4.2, SMA5.2, SMA6.2, SMA7.2, SMA8.2, SMA9.2, SMA10.2, SMA11.2, SMA12.2, SMA13.2, SMA14.2, SMA15.2, SMA16.2, SMA18.2, SMA20.2, SMA23.2, SMA24.2, SMA28.2, SMA30.2
unnamed: SMA1.1, SMA2.1
unnamed: SMA3.1, SMA4.1
unnamed: SMA5.1, SMA6.1
unnamed: SMA7.1, SMA8.1
unnamed: SMA9.1, SMA10.1
unnamed: SMA11.1, SMA16.1
unnamed: SMA12.1, SMA14.1
unnamed: SMA13.1, SMA18.1
unnamed: SMA15.1, SMA20.1
unnamed: SMA23.1, SMA24.1
unnamed: SMA28.1, SMA30.1

## KiCad design Filter_0603_vertical/Filter_0603_vertical.kicad_pcb

Board: 2 copper layers, 46.4 x 33.7 mm, 4 parts (2 on the bottom side), 3 nets.

Parts:
SMA1, SMA2: SMA_KHD_Back
U1: Filter_0603
outline1: Outline_3x2_cavity_1.5mm

Connections:
GND: SMA1.2, SMA2.2, U1.2 (GND), outline1.1 (GND)
unnamed: SMA1.1, U1.1 (IN)
unnamed: SMA2.1, U1.3 (OUT)

File Filter_0603_vertical/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"SMA1, SMA2",SMA_KHD_Back,2,~,
U1,Filter_0603,1,~,
outline1,Outline_2x2_cavity_20231207,1,~,
