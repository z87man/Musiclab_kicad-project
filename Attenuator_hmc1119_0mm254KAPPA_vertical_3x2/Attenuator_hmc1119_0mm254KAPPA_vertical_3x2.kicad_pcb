# Repository z87man/Musiclab_kicad-project (continued)

## KiCad design Mixer_wuxh_cavity/Mixer_wuxh_cavity.kicad_pcb

Parts:
SMA1, SMA2, SMA3: SMA_KHD_Back
U1: Mixer_SIM73L
outline1: Outline_3x2_cavity_1.5mm

Connections:
/IF: SMA3.1, U1.2 (IF)
GND: SMA1.2, SMA2.2, SMA3.2, U1.1 (GND), U1.3 (GND), U1.5 (GND), U1.6 (GND), U1.7 (GND), U1.9 (GND), outline1.1 (GND)
unnamed: SMA2.1, U1.8 (LO)
unnamed: SMA1.1, U1.4 (RF)

Board: 2 copper layers, 46.5 x 33.8 mm, 5 parts (3 on the bottom side), 4 nets.

## KiCad design PLL_LMX2594_0mm254_KAPPA_3x2/PLL_LMX2594_0mm254_KAPPA_3x2.kicad_pcb

Parts:
C1, C2, C4, C5, C7: 10uF; C_0402_1005Metric
C3, C6, C9, C10, C11, C12, C13, C23: 1uF; C_0402_1005Metric
C8, C14, C16, C20, C21, C22, C24: 0.1uF; C_0402_1005Metric
C15, C19: 0.01uF; C_0402_1005Metric
C17: 0.1 uF; C_0402_1005Metric
C18: 10 uF; C_0402_1005Metric
C20_LF1: 2.2nF; C_0402_1005Metric
C21_LF1: C_Small; C_0402_1005Metric; not fitted
C22_LF1: 470nF; C_0402_1005Metric
C23_LF1: 330 pF; C_0402_1005Metric
C25: 0.1nF; C_0402_1005Metric
D1: LED; LED_0603_1608Metric
D2: TVS SMAJ3.3A-TP; TVS DIOM5226X230N; Mouser Part Number 833-SMAJ6.0A-TP
D3: D_Schottky; D_SOD-323
D4: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; not fitted
FB1: Bead MG1608-152Y; Bead0603 BEADC1608X100N; Mouser Part Number 652-MG1608-152Y
J1, J6, J7, J8, J9: Conn_Coaxial; SMA_KHD_Back
J2: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J10: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
L1, L2: 18nH; L_0603_1608Metric
Q1: Q_PMOS_GSD; SOT-23
R1, R2, R3, R7: 50; R_0402_1005Metric
R4: 100k; R_0402_1005Metric
R5: 330; R_0402_1005Metric
R5_LF1: 22; R_0402_1005Metric
R6, R8, R9: 12K; R_0402_1005Metric
R6_LF1: 0; R_0402_1005Metric
R7_LF1: 15; R_0402_1005Metric
R10, R11: 51; R_0402_1005Metric
R12: 10 kohm; R_0402_1005Metric
R13: 10 kohm; R_0402_1005Metric; not fitted
U1: LMX2594-QFN41N
outline1: Outline_3x2_cavity_1.5mm

Connections:
/CPOUT: C22_LF1.2, C23_LF1.2, R6_LF1.2, U1.12 (CPOUT)
/CSB: R6.1, U1.24 (CSB)
/MUXOUT: J10.6, U1.20 (MUXOUT)
/OSCINP+: C20.2, U1.9 (OSCINM)
/OSCINP-: C21.1, U1.8 (OSCINP)
/RAMPCIK: J4.6, U1.5 (SYNC)
/RAMPDIR: J4.1, U1.28 (SYSREFREQ)
/RFoutAM+: C14.2, R1.2, U1.23 (RFOUTAP)
/RFoutAM-: C16.2, R2.2, U1.22 (RFOUTAM)
/RFoutBM+: C22.2, R3.2, U1.19 (RFOUTBP)
/RFoutBM-: C24.2, R7.2, U1.18 (RFOUTBM)
/SCK: R9.2, U1.16 (SCK)
/SDI: R8.1, U1.17 (SDI)
/SYNC: J4.3, U1.30 (RAMPCIK)
/SYSREFREQ: J4.5, U1.32 (RAMPDIR)
/VCC: C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, C17.2, C25.2, FB1.2, L1.1, L2.1, R4.1, U1.7 (VCCDIG), U1.11 (VCCCP), U1.15 (VCCMASH), U1.21 (VCCBUF), U1.26 (VCCVCO2), U1.37 (VCCVCO)
/VTUNER: C20_LF1.2, R5_LF1.1, U1.35 (VTUNE)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C15.1, C17.1, C18.1, C19.1, C20_LF1.1, C21_LF1.1, C23.1, C23_LF1.1, C25.1, D1.1 (K), D2.2 (A), J1.2 (Ext), J2.1, J4.2, J4.4, J6.2 (Ext), J7.2 (Ext), J8.2 (Ext), J9.2 (Ext), J10.2, R7_LF1.2, R10.1, R11.2, R12.1, R13.1, U1.2 (VCO_GND), U1.4 (VCO_GND), U1.6 (DGND), U1.13 (PUMP_GND), U1.14 (DGND), U1.25 (VCO_GND), U1.31 (VCO_GND), U1.34 (VCO_GND), U1.39 (VCO_GND), U1.40 (VCO_GND), U1.41 (DAP_GND), outline1.1 (GND)
unnamed: C15.2, L1.2, R1.1, R2.1
unnamed: C19.2, L2.2, R3.1, R7.1
unnamed: C21.2, R11.1
unnamed: C21_LF1.2, R5_LF1.2, R6_LF1.1
unnamed: C22_LF1.1, R7_LF1.1
unnamed: D1.2 (A), R5.2
unnamed: C18.2, C23.2, D2.1 (K), D3.1 (K), D4.1 (K), FB1.1, Q1.2 (S)
unnamed: D3.2 (A), Q1.1 (G), R12.2
unnamed: D4.2 (A), R13.2
unnamed: C14.1, J1.1 (In)
unnamed: J2.2, Q1.3 (D)
unnamed: C16.1, J6.1 (In)
unnamed: C22.1, J7.1 (In)
unnamed: C24.1, J8.1 (In)
unnamed: C20.1, J9.1 (In), R10.2
unnamed: J10.1, R6.2
unnamed: J10.3, R8.2
unnamed: J10.4, R9.1
unnamed: J10.5, R5.1
unnamed: R4.2, U1.1 (CE)
unnamed: C5.1, U1.33 (VBIASVARAC)
unnamed: C7.1, U1.27 (VBIASVCO2)
unnamed: C4.1, U1.3 (VBIASVCO)
unnamed: C2.1, U1.29 (VREFVCO2)
unnamed: C1.1, U1.36 (VREFVCO)
unnamed: C3.1, U1.10 (VREGIN)
unnamed: C6.1, U1.38 (VREGVCO)

Notes on the sheet:
2.ESD及浪涌防护
Diode_SMD:D_SOD-323
滤特定高频频率噪声 看需求放置
PMOS： Package_TO_SOT_SMD:SOT-23
6.电源滤波
5.磁珠0603
3. 电源指示灯
4. 电源滤波
footprint：查询SMAJ3.3A DIOM5226X230N
1.防反接

Board: 4 copper layers, 46.5 x 33.8 mm, 61 parts (10 on the bottom side), 44 nets.

File PLL_LMX2594_0mm254_KAPPA_3x2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C4, C5, C7",0402,5,10uF,
"C10, C11, C12, C13, C23, C3, C6, C9",0402,8,1uF,
"C14, C16, C20, C21, C22, C24, C8",0402,7,0.1uF,
"C15, C19",0402,2,0.01uF,
C17,0402,1,0.1 uF,
C18,0402,1,10 uF,
C20_LF1,0402,1,2.2nF,
C21_LF1,0402,1,C_Small,
C22_LF1,0402,1,470nF,
C23_LF1,0402,1,330 pF,
C25,0402,1,0.1nF,
D1,0603,1,LED,
D2,TVS DIOM5226X230N,1,TVS SMAJ3.3A-TP,
D3,D_MicroMELF,1,D_Schottky,
FB1,Bead0603 BEADC1608X100N,1,Bead MG1608-152Y,
"J1, J6, J7, J8, J9",SMA_KHD_Back,5,Conn_Coaxial,
J2,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
J3,PinHeader_1x02_P2.54mm_Vertical,1,Conn_01x02_Pin,
J4,PinHeader_2x03_P2.54mm_Vertical,1,Conn_02x03_Odd_Even,
J5,PinHeader_2x02_P2.54mm_Vertical,1,Conn_02x02_Odd_Even,
"L1, L2",0603,2,18nH,
Q1,SOT-23,1,Q_PMOS_GSD,
"R1, R2, R3, R7",0402,4,50,
"R10, R11",0402,2,51,
R12,0402,1,10 kohm,
R4,0402,1,100k,
R5,0402,1,330,
R5_LF1,0402,1,22,
"R6, R8, R9",0402,3,12K,
R6_LF1,0402,1,0,
R7_LF1,0402,1,15,
U1,LMX2594-QFN41N,1,~,
outline1,Outline_3x2_cavity_1.5mm,1,~,
