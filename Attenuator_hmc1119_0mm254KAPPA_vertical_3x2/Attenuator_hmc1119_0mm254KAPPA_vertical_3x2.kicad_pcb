# Repository z87man/Musiclab_kicad-project

## KiCad design Attenuator_hmc1119_0mm254KAPPA_vertical_3x2/Attenuator_hmc1119_0mm254KAPPA_vertical_3x2.kicad_pcb

Parts:
C1, C4, C5, C6, C7, C8, C9, C10, C11, C12: 100pF; C_0402_1005Metric
C15: 10 uF; C_0402_1005Metric
C16: 1uF; C_0402_1005Metric
C17: 0.1 uF; C_0402_1005Metric
C18: 0.1nF; C_0402_1005Metric
D1: D_Schottky; D_SOD-323
D2: TVS SMAJ3.3A-TP; TVS DIOM5226X230N; Mouser Part Number 833-SMAJ6.0A-TP
D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: Bead MG1608-152Y; Bead0603 BEADC1608X100N; Mouser Part Number 652-MG1608-152Y
IC1: HMC1119LP4METR; Antennuator-HMC1119-QFN50P400X400X95-25N-D; Mouser Part Number 584-HMC1119LP4METR
J1: Conn_02x07_Counter_Clockwise; SW_DIP_SPSTx07_Slide_6.7x19.34mm_W7.62mm_P2.54mm_LowProfile
J2: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical
Q1: Q_PMOS_GSD; SOT-23
R1, R19: 0; R_0402_1005Metric
R2, R3, R4, R5, R6, R7, R8, R9, R10, R21, R22: 100k; R_0402_1005Metric
R11, R12, R13, R14, R15, R16, R17, R18: 1k; R_0402_1005Metric
R20, R23: 10 kohm; R_0402_1005Metric
SMA1, SMA2: SMA_KHD_Back
outline1: Outline_3x2_cavity_1.5mm

Connections:
/CLK: J5.5, R19.2
/DATAIN: J5.4, R1.2
/LE: IC1.16 (LE), J5.6, R22.2
/P/S: C1.1, IC1.3 (P/S), J5.2, R21.2
/Vdd: C17.2, C18.2, FB1.2, IC1.2 (VDD), R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2
GND: C1.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.1, C16.1, C17.1, C18.1, D2.2 (A), IC1.4 (GND_1), IC1.6 (GND_2), IC1.7 (GND_3), IC1.8 (GND_4), IC1.9 (GND_5), IC1.10 (GND_6), IC1.11 (GND_7), IC1.12 (GND_8), IC1.13 (GND_9), IC1.15 (GND_10), IC1.25 (GND_11), J2.1, J5.3, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R20.1, R21.1, R22.1, R23.1, SMA1.2, SMA2.2, outline1.1 (GND)
unnamed: C4.2, SMA1.1
unnamed: C7.2, SMA2.1
unnamed: D1.2 (A), Q1.1 (G), R20.2
unnamed: C15.2, C16.2, D1.1 (K), D2.1 (K), D3.1 (K), FB1.1, Q1.2 (S)
unnamed: D3.2 (A), R23.2
unnamed: C4.1, IC1.5 (ATTNIN)
unnamed: C7.1, IC1.14 (ATTNOUT)
unnamed: IC1.17 (CLK), R4.2, R19.1
unnamed: C12.1, IC1.1 (D0), J1.14, R10.2
unnamed: C11.1, IC1.24 (D1), J1.13, R9.2
unnamed: C10.1, IC1.23 (D2), J1.12, R8.2
unnamed: C9.1, IC1.22 (D3), J1.11, R6.2
unnamed: C8.1, IC1.21 (D4), J1.10, R5.2
unnamed: C6.1, IC1.20 (D5), J1.9, R3.2
unnamed: C5.1, IC1.19 (D6), J1.8, R2.2
unnamed: IC1.18 (SERNIN), R1.1, R7.2
unnamed: J1.1, R11.1
unnamed: J1.2, R12.1
unnamed: J1.3, R13.1
unnamed: J1.4, R14.1
unnamed: J1.5, R15.1
unnamed: J1.6, R16.1
unnamed: J1.7, R17.1
unnamed: J2.2, Q1.3 (D)
unnamed: J5.1, R18.1

Notes on the sheet:
6.电源滤波
滤特定高频频率噪声 看需求放置
2.ESD及浪涌防护
4. 电源滤波
footprint：查询SMAJ3.3A DIOM5226X230N
1.防反接
5.磁珠0603
D1：Diode_SMD:D_MELF更换为Diode_SMD: SOD-323
3. 电源指示灯
PMOS： Package_TO_SOT_SMD:SOT-23

Board: 4 copper layers, 46.5 x 33.8 mm, 49 parts (5 on the bottom side), 31 nets.

File Attenuator_hmc1119_0mm254KAPPA_vertical_3x2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C4, C5, C6, C7, C8, C9",0402,10,100pF,
C15,0402,1,10 uF,
C16,0402,1,1uF,
C17,0402,1,0.1 uF,
C18,0402,1,0.1nF,
D1,D_MicroMELF,1,D_Schottky,
D2,TVS DIOM5226X230N,1,TVS SMAJ3.3A-TP,
D3,0603,1,LED,
FB1,Bead0603 BEADC1608X100N,1,Bead MG1608-152Y,
IC1,Antennuator-HMC1119-QFN50P400X400X95-25N-D,1,HMC1119LP4METR,
J1,SW_DIP_SPSTx07_Slide_6.7x19.34mm_W7.62mm_P2.54mm_LowProfile,1,Conn_02x07_Counter_Clockwise,
J2,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
J5,PinHeader_2x03_P2.54mm_Vertical,1,Conn_02x03_Odd_Even,
Q1,SOT-23,1,Q_PMOS_GSD,
"R1, R19",0402,2,0,
"R10, R2, R21, R22, R3, R4, R5, R6, R7, R8, R9",0402,11,100k,
"R11, R12, R13, R14, R15, R16, R17, R18",0402,8,1k,
"R20, R23",0402,2,10 kohm,
"SMA1, SMA2",SMA_KHD_Back,2,~,
outline1,Outline_3x2_cavity_1.5mm,1,~,

## KiCad design Filter_3.2x1.6_vertical/Filter_3.2x1.6_vertical.kicad_pcb

Parts:
SMA1, SMA2: SMA_KHD_Back
U2: Filter_3.2x1.6
outline1: Outline_2x2_cavity_20231207

Connections:
GND: SMA1.2, SMA2.2, U2.2 (GND), outline1.1 (GND)
unnamed: SMA1.1, U2.1 (IN)
unnamed: SMA2.1, U2.3 (OUT)

Board: 2 copper layers, 33.6 x 33.6 mm, 4 parts (2 on the bottom side), 3 nets.

File Filter_3.2x1.6_vertical/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"SMA1, SMA2",SMA_KHD_Back,2,~,
U2,Filter_3.2x1.6,1,~,
outline1,Outline_2x2_cavity_20231207,1,~,

## KiCad design Hybrid_QCN-3+/Hybrid_QCN-3+.kicad_pcb

Board: 2 copper layers, 16.4 x 10.0 mm, 6 parts (0 on the bottom side), 5 nets.

Parts:
IC2: Hybrid_QCN-3+; Hybrid_QCN3
R1: R; R_0402_1005Metric
SMA1, SMA2, SMA3: SMA_Edge_KD_2mm
outline1: Outline_1.5x1

Connections:
GND: IC2.2 (GROUND_1), IC2.5 (GROUND_2), R1.2, outline1.1 (GND)
unnamed: IC2.3 (50_OHM_TERM_EXTERNAL_), R1.1
unnamed: IC2.4 (PORT_1_(0°)), SMA2.1
unnamed: IC2.6 (PORT_2_(+90°)), SMA3.1
unnamed: IC2.1 (SUM_PORT), SMA1.1

File Hybrid_QCN-3+/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
IC2,Hybrid_QCN3,1,Hybrid_QCN-3+,
R1,0402,1,R,
"SMA1, SMA2, SMA3",SMA_Edge_KD_2mm,3,~,
outline1,Outline_1.5x1,1,~,

## KiCad design IF_20240930/IF_20240930.kicad_pcb

Parts:
C3: 0.1uF; C_0603_1608Metric
C4, C10, C17, C18, C20, C23: 1uf; C_0603_1608Metric
C5: 0.1nF; C_0603_1608Metric
C9, C26: 4.7u; C_0603_1608Metric
C16: 0.1uf; C_0603_1608Metric
C19: 4.7uf; C_0603_1608Metric
C21, C24: 1n; C_0603_1608Metric
C22: 1.2n; C_0603_1608Metric
C25: 7.15n; C_0603_1608Metric
IC1: MIC7300; DC_SOT95P280X145-5N; Mouser Part Number 595-LMV321IDBVR
IC2: OPA134UA; OPA134_SOIC127P600X175-8N; Mouser Part Number 595-OPA134UA
IC3: OPA2134UA_2K5; OPA2134_SOIC127P600X175-8N; Mouser Part Number 595-OPA2134UA/2K5
J1, J2: Conn_01x02_Pin; SMA_KHD_Back
J3: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J4, J5: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R3: 1k; R_0603_1608Metric
R4: 300k; R_0603_1608Metric
R5: 12k; R_0603_1608Metric
R6: 17.4k; R_0603_1608Metric
R7: 4.75k; R_0603_1608Metric
R8: 7.5k; R_0603_1608Metric
R15, R16: 33k; R_0603_1608Metric
RV2: R_Potentiometer; Potentiometer_Bourns_3296W_Vertical
outline1: Outline_3x2_cavity_1.5mm

Connections:
/Vcm_IF: C10.1, C16.1, C18.1, C20.1, IC1.1 (OUT), IC1.4 (1IN-), R3.2, R4.2
/Vdd: C3.1, C5.1, C17.1, C19.1, C23.1, IC1.5 (V+), IC2.7 (V+), IC3.8 (V+), J3.2, R15.2
GND: C3.2, C4.2, C5.2, C10.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C23.2, C24.2, IC1.2 (V-), IC2.4 (V-), IC3.4 (V-), J1.2, J2.2, J3.1, J4.1, J5.1, R16.1, outline1.1 (GND)
unnamed: C22.1, R5.2, R6.1
unnamed: C25.2, R7.2, R8.1
unnamed: C4.1, IC1.3 (1IN+), R15.1, R16.2
unnamed: C9.2, IC2.3 (+IN), R4.1
unnamed: IC2.2 (-IN), R3.1, RV2.3
unnamed: IC2.6 (OUTPUT), R5.1, RV2.2
unnamed: C21.1, IC3.3 (+INA), R6.2
unnamed: C24.1, IC3.5 (+IN_B), R8.2
unnamed: C22.2, IC3.1 (OUTA), IC3.2 (-INA), R7.1
unnamed: C25.1, C26.1, IC3.6 (-IN_B), IC3.7 (OUT_B)
unnamed: C9.1, J1.1, J4.2
unnamed: C26.2, J2.1, J5.2

Notes on the sheet:
+5V/+10V

Board: 4 copper layers, 46.5 x 33.8 mm, 34 parts (6 on the bottom side), 15 nets.

File IF_20240930/production/IF_20240930bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C10, C17, C18, C20, C23, C4",0603,6,1uf,
"C16, C3",0603,2,0.1uf,
C19,0603,1,4.7uf,
"C21, C24",0603,2,1n,
C22,0603,1,1.2n,
C25,0603,1,7.15n,
"C26, C9",0603,2,4.7u,
C5,0603,1,0.1nF,
IC1,DC_SOT95P280X145-5N,1,MIC7300,
IC2,OPA134_SOIC127P600X175-8N,1,OPA134UA,
IC3,OPA2134_SOIC127P600X175-8N,1,OPA2134UA_2K5,
"J1, J2",SMA_KHD_Back,2,Conn_01x02_Pin,
J3,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
"J4, J5",PinHeader_1x02_P2.54mm_Vertical,2,Conn_01x02_Pin,
"R15, R16",0603,2,33k,
R3,0603,1,1k,
R4,0603,1,300k,
R5,0603,1,12k,
R6,0603,1,17.4k,
R7,0603,1,4.75k,
R8,0603,1,7.5k,
RV2,Potentiometer_Bourns_3296W_Vertical,1,R_Potentiometer,
outline1,Outline_3x2_cavity_20231207,1,~,

## KiCad design IF_Combiner/IF_combine_inverting/IFcombine_invert/IFcombine_invert.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C7: 4.7uf; C_0603_1608Metric
C5, C12: 1uf; C_0603_1608Metric
C8, C9, C10, C11: 0.1uf; C_0402_1005Metric
IC1: MIC7300; SOT-23-5; Mouser Part Number 595-LMV321IDBVR
J1, J2, J4: Conn_01x02_Pin; SMA_KHD_Back
J3: Conn_01x02_Pin; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
R1, R2, R3, R4, R7: 1k; C_0402_1005Metric
R5, R6: 33k; C_0402_1005Metric
R8: 330; C_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7: TestPoint; TestPoint_Plated_Hole_D0.6mm
U1, U2, U3: SOIC-8_3.9x4.9mm_P1.27mm
outline2: Outline_4x2_cavity_20231207

Connections:
/Vcm_IF: C8.1, C9.1, C10.1, C11.1, C12.1, IC1.1 (OUT), IC1.4 (1IN-), R1.1, R2.1, R8.2
/Vdd: C2.1, IC1.5 (V+), J3.2, R5.2, U1.7 (V+), U2.7 (V+), U3.7 (V+)
GND: C2.2, C5.2, C8.2, C9.2, C10.2, C11.2, C12.2, IC1.2 (V-), J1.2, J2.2, J3.1, J4.2, R6.1, TP4.1, TP5.1, TP6.1, TP7.1, U1.4 (V-), U2.4 (V-), U3.4 (V-), outline2.1 (GND)
unnamed: C4.2, R3.2
unnamed: C6.2, R4.2
unnamed: C5.1, IC1.3 (1IN+), R5.1, R6.2
unnamed: C1.1, J1.1, TP1.1
unnamed: C3.1, J2.1, TP2.1
unnamed: C7.2, J4.1, TP3.1
unnamed: C4.1, U1.2 (in-), U1.6 (Out)
unnamed: C1.2, R1.2, U1.3 (in+)
unnamed: C6.1, U2.2 (in-), U2.6 (Out)
unnamed: C3.2, R2.2, U2.3 (in+)
unnamed: C7.1, R7.1, U3.6 (Out)
unnamed: R8.1, U3.3 (in+)
unnamed: R3.1, R4.1, R7.2, U3.2 (in-)

Notes on the sheet:
+5V/+10V

Board: 4 copper layers, 59.0 x 33.6 mm, 36 parts (9 on the bottom side), 16 nets.

File IF_Combiner/IF_combine_inverting/IFcombine_invert/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C6, C7",0603,6,4.7uf,
"C10, C11, C8, C9",0402,4,0.1uf,
"C12, C5",0603,2,1uf,
IC1,SOT-23-5,1,MIC7300,
"J1, J2, J4",SMA_KHD_Back,3,Conn_01x02_Pin,
J3,JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
"R1, R2, R3, R4, R7",0402,5,1k,
"R5, R6",0402,2,33k,
R8,0402,1,330,
"TP1, TP2, TP3, TP4, TP5, TP6, TP7",TestPoint_Plated_Hole_D0.6mm,7,TestPoint,
"U1, U2, U3",SOIC-8_3.9x4.9mm_P1.27mm,3,~,
outline2,Outline_4x2_cavity_20231207,1,~,

## KiCad design LNA_PM3-14LN+_cavity_20230729/LNA_PM3-14LN+_cavity_20230729.kicad_pcb

Parts:
C1, C4, C5: 0.1uF; C_0603_1608Metric_revised
C2, C6: 0.1pF; C_0603_1608Metric_revised
C3: 100pF; C_0603_1608Metric_revised
C7: 22uF; C_0603_1608Metric_revised
C8: 1uF; C_0603_1608Metric_revised
C9: 10pF; C_0603_1608Metric_revised
IC1: PMA3-14LN+; LNA_PMA3-14LN+; Manufacturer_Part_Number PMA3-14LN+; Mouser Part Number 139-PMA3-14LN+
J1: Conn_01x02_Pin; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
L1, L2: 15nH; L_0603_1608Metric_revised
R1: 510; R_0603_1608Metric_revised
SMA1, SMA2: SMA_KHD
outline1: Outline_3x2_cavity_20230729

Connections:
GND: C2.1, C3.1, C4.1, C6.1, C7.2, C8.2, C9.2, IC1.3 (NC_1), IC1.4 (NC_2), IC1.5 (NC_3), IC1.6 (NC_4), IC1.7 (NC_5), IC1.9 (NC_6), IC1.10 (NC_7), IC1.11 (NC_8), IC1.12 (NC_9), IC1.13 (GND), J1.1, R1.1, SMA1.2, SMA2.2, outline1.1 (GND)
unnamed: C1.1, SMA1.1
unnamed: C5.1, SMA2.1
unnamed: C3.2, C4.2, IC1.1 (CURRENT_MIRROR), L1.1, R1.2
unnamed: C1.2, C2.2, IC1.2 (RF-IN), L1.2
unnamed: C5.2, C6.2, IC1.8 (RF-OUT_&_VDD), L2.2
unnamed: C7.1, C8.1, C9.1, J1.2, L2.1

Board: 2 copper layers, 46.3 x 33.6 mm, 17 parts (4 on the bottom side), 7 nets.

File LNA_PM3-14LN+_cavity_20230729/production/LNA_PM3-14LN_cavity_bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C4, C5",0603,3,0.1uF,
C2,0603,1,0.2pF,
C3,0603,1,100pF,
C6,0603,1,0.1pF,
C7,0603,1,22uF,
C8,0603,1,4.7uF,
C9,0603,1,10pF,
IC1,LNA_PMA3-14LN+,1,PMA3-14LN+,
J1,JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical,1,Conn_01x02_Pin,
"L1, L2",0603,2,15nH,
R1,0603,1,510,
"SMA1, SMA2",SMA_KHD,2,~,
outline1,Outline_3x2_cavity_20230729,1,~,
